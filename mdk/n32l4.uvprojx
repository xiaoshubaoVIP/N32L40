# Keil uVision project n32l4.uvprojx, settings and files
target n32l4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32L406CB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: n32l4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c misc: --gnu
  c include: ..\code\ap\inc;..\code\bsp\;..\code\lib_drv\n32l406x\core;..\code\lib_drv\n32l406x\inc;..\code\modules;..\code\system;..\code\modules\radio\inc;..\code\system\shell\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group ap
    ../code/ap/src/: app_co.c app_main.c debug.c app_smoke.c main.c SceneInstance.c app_rf.c
  group bsp
    ../code/bsp/n32l4/src/: board.c hal_adc.c hal_flash.c hal_gpio.c hal_lcd.c hal_rtc.c hal_tim.c hal_uart.c hal_watchdog.c
  group lib_drv
    ../code/lib_drv/n32l406x/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_tsc.c n32l40x_usart.c n32l40x_wwdg.c system_n32l40x.c
    ../code/lib_drv/n32l406x/startup/: startup_n32l40x.s
  group modules
    ../code/modules/src/: Beep.c co.c key.c KeyAnalysis.c lcd.c led.c PwrManager.c smoke.c temp.c
    ../code/modules/radio/src/: radio_2300a.c radio_2300a_driver.c radio_2300a_spi.c radio_protocol.c
  group system
    ../code/system/: system.c qep_port.c polling.c list.c
    ../code/system/qep/src/: qeq_fifo.c qfsm_dis.c qep.c
  group describe
    ../code/bsp/n32l4/sc/: sc01_describe.c sc200_describe.c
    ../code/bsp/n32l4/xc/: xc01_describe.c
  group shell
    ../code/system/shell/src/: shell.c shell_ext.c
